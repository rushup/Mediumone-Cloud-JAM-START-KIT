# IAR project Cloud-JAM-EWARM.ewp, settings and files
configuration Cloud-JAM-EWARM (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; USE_STM32F4XX_NUCLEO
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\..\Common\App\Inc; ..\..\Common; ..\..\Common\MQTT-Paho\MQTTClient-C\src; ..\..\Common\MQTT-Paho\MQTTPacket\src; ..\..\Common\Nucleo\Components; ..\..\Common\Nucleo\X_NUCLEO_IKS01A2; ..\..\Common\Nucleo\X-NUCLEO-NFC01A1
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Cloud-JAM-EWARM.bin
  ILINK.IlinkOutputFile: Cloud-JAM-EWARM.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/App
    ../../Common/App/Src/: app.c m1_mouserkit.c parson.c platform_gnu.c platform_iks01a2.c platform_mqtt.c platform_tim.c platform_usart.c platform_usb.c platform_wifi.c
  group Application/EWARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../Src/: crc.c dma.c gpio.c i2c.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c tim.c usart.c
  group Drivers/ATBOX
    ../../Common/atbox/at/: at.c
    ../../Common/atbox/net/wifi/spwf01sa/: spwf01sa.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
    ..//Src/: system_stm32f4xx.c
  group Drivers/MQTT
    ../../Common/MQTT-Paho/MQTTClient-C/src/: MQTTClient.c
    ../../Common/MQTT-Paho/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group Drivers/Nucleo
    ../../Common/Nucleo/X-NUCLEO-NFC01A1/: drv_I2C_M24SR.c lib_ISO7816_Password.c lib_NDEF.c lib_NDEF_AAR.c lib_NDEF_Email.c lib_NDEF_Geo.c lib_NDEF_MyApp.c lib_NDEF_SMS.c lib_NDEF_URI.c lib_NDEF_Vcard.c lib_NDEF_Wifi.c lib_STProprietary_feature.c lib_TagType4.c
    ../../Common/Nucleo/Components/: HTS221_Driver.c HTS221_Driver_HL.c IIS2DH_Driver.c IIS2DH_Driver_HL.c lib_M24SR.c LPS22HB_Driver.c LPS22HB_Driver_HL.c LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c LSM303AGR_MAG_driver.c LSM303AGR_MAG_driver_HL.c LSM6DSL_ACC_GYRO_driver.c LSM6DSL_ACC_GYRO_driver_HL.c m24sr.c
    ../../Common/Nucleo/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2_accelero.c x_nucleo_iks01a2_gyro.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_magneto.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_temperature.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
